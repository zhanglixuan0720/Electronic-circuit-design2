# Keil uVision project Lab1.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Lab1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group Source Group 1
    ./: STARTUP.A51
  group source file
    ./source/: adc.c lcd.c led.c main.c port.c queue.c timer.c pid.c menu.c status.c
  group header file
    ./include/: C8051F020.h adc.h def_com.h lcd.h led.h port.h queue.h timer.h image.h pid.h menu.h status.h
